# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: AT32F403AVGT7 ArteryTek
  pack: Keil.AT32F4xx_DFP.1.3.1
  cpu: IRAM(0x20000000,0x38000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, AT32F403AVGT7, RT_USING_ARM_LIBC
  c include: .;rt-thread\include;applications;.;board;board\msp;Libraries\rt_drivers;packages\bc28_mqtt-latest\inc;packages\dhtxx-latest\inc;packages\gp2y10-latest\inc;packages\littled-latest\inc;packages\sgp30-latest\inc;rt-thread\libcpu\arm\common;rt-thread\libcpu\arm\cortex-m4;rt-thread\components\dfs\include;rt-thread\components\dfs\filesystems\devfs;rt-thread\components\dfs\filesystems\elmfat;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\sensors;rt-thread\components\drivers\include;rt-thread\components\finsh;rt-thread\components\libc\compilers\armlibc;rt-thread\components\libc\compilers\common;rt-thread\components\net\at\include;Libraries\AT32_Std_Driver\CMSIS\AT32\AT32F4xx\inc;Libraries\AT32_Std_Driver\CMSIS;Libraries\AT32_Std_Driver\AT32F4xx_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x38000
  scatter file: .\board\linker_scripts\link.sct
  group Kernel
    rt-thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group Applications
    applications/: main.c rt_hw_us_delay.c
  group Drivers
    board/: board.c
    board/msp/: at32_msp.c system_at32f4xx.c
    Libraries/AT32_Std_Driver/CMSIS/AT32/AT32F4xx/src/mdk/: startup_at32f403avgt7.s
    Libraries/rt_drivers/: drv_gpio.c drv_usart.c drv_soft_i2c.c drv_adc.c
  group bc28-mqtt
    packages/bc28_mqtt-latest/src/: bc28_mqtt.c
  group dhtxx
    packages/dhtxx-latest/src/: dhtxx.c sensor_asair_dhtxx.c
  group gp2y10
    packages/gp2y10-latest/src/: gp2y10.c sensor_sharp_gp2y10.c
  group littled
    packages/littled-latest/src/: littled.c
  group sgp30
    packages/sgp30-latest/src/: sgp30.c sensor_sensirion_sgp30.c
  group cpu
    rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
  group Filesystem
    rt-thread/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c poll.c select.c
    rt-thread/components/dfs/filesystems/devfs/: devfs.c
    rt-thread/components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
    rt-thread/components/dfs/filesystems/elmfat/option/: ccsbcs.c
  group DeviceDrivers
    rt-thread/components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    rt-thread/components/drivers/misc/: pin.c adc.c
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
  group Sensors
    rt-thread/components/drivers/sensors/: sensor.c sensor_cmd.c
  group finsh
    rt-thread/components/finsh/: shell.c cmd.c msh.c msh_file.c
  group libc
    rt-thread/components/libc/compilers/armlibc/: libc.c mem_std.c stdio.c stubs.c
    rt-thread/components/libc/compilers/common/: time.c
  group AT
    rt-thread/components/net/at/src/: at_utils.c at_cli.c at_client.c
  group AT32_Lib
    Libraries/AT32_Std_Driver/AT32F4xx_StdPeriph_Driver/src/: at32f4xx_adc.c at32f4xx_can.c at32f4xx_crc.c at32f4xx_dbgmcu.c at32f4xx_dma.c at32f4xx_exti.c at32f4xx_flash.c at32f4xx_gpio.c at32f4xx_i2c.c at32f4xx_iwdg.c at32f4xx_pwr.c at32f4xx_rcc.c at32f4xx_spi.c at32f4xx_tim.c at32f4xx_usart.c at32f4xx_wwdg.c at32f4xx_sdio.c at32f4xx_acc.c at32f4xx_bkp.c at32f4xx_rtc.c at32f4xx_ertc.c at32f4xx_eth.c at32f4xx_xmc.c at32f4xx_comp.c at32f4xx_dac.c misc.c
