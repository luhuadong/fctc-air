# IAR project project.ewp, settings and files
configuration rtthread (ARM, debug)
  General.OGChipSelectEditMenu: STM32H743ZI ST STM32H743ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: STM32H750xx; __RTTHREAD__; USE_HAL_DRIVER
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: libraries/HAL_Drivers/config; libraries/STM32H7xx_HAL/CMSIS/Include; board; rt-thread/libcpu/arm/common; rt-thread/components/libc/compilers/common; rt-thread/libcpu/arm/cortex-m7; libraries/HAL_Drivers; rt-thread/components/libc/compilers/common/none-gcc; rt-thread/components/finsh; board/CubeMX_Config/Core/Inc; .; libraries/STM32H7xx_HAL/CMSIS/Device/ST/STM32H7xx/Include; rt-thread/components/drivers/include; rt-thread/include; libraries/STM32H7xx_HAL/STM32H7xx_HAL_Driver/Inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../../rtthread.bin
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: main.c
  group CPU
    rt-thread/libcpu/arm/common/: div0.c showmem.c backtrace.c
    rt-thread/libcpu/arm/cortex-m7/: cpuport.c cpu_cache.c context_iar.S
  group DeviceDrivers
    rt-thread/components/drivers/misc/: pin.c
    rt-thread/components/drivers/src/: ringblk_buf.c ringbuffer.c dataqueue.c waitqueue.c workqueue.c pipe.c completion.c
    rt-thread/components/drivers/serial/: serial.c
  group Drivers
    ../libraries/STM32H7xx_HAL/CMSIS/Device/ST/STM32H7xx/Source/Templates/iar/: startup_stm32h750xx.s
    board/: board.c
    board/CubeMX_Config/Core/Src/: stm32h7xx_hal_msp.c
    libraries/HAL_Drivers/: drv_gpio.c drv_usart.c drv_common.c
  group finsh
    rt-thread/components/finsh/: shell.c cmd.c msh.c
  group Kernel
    rt-thread/src/: components.c irq.c clock.c idle.c device.c mempool.c timer.c kservice.c ipc.c object.c mem.c scheduler.c thread.c
  group libc
    rt-thread/components/libc/compilers/common/: time.c
  group Libraries
    libraries/STM32H7xx_HAL/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_sram.c stm32h7xx_hal_usart.c stm32h7xx_hal_cryp.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_dma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_uart.c stm32h7xx_hal_cryp_ex.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_rng.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_crc.c stm32h7xx_hal.c stm32h7xx_hal_rcc.c stm32h7xx_hal_cortex.c stm32h7xx_hal_cec.c stm32h7xx_hal_comp.c stm32h7xx_hal_dma_ex.c
    libraries/STM32H7xx_HAL/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
