# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H750XBHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.5.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00020000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: USE_HAL_DRIVER, __RTTHREAD__, __CLK_TCK=RT_TICK_PER_SECOND, STM32H750xx
  c include: rt-thread/libcpu/arm/common;rt-thread/libcpu/arm/cortex-m7;rt-thread/components/drivers/include;rt-thread/components/drivers/include;rt-thread/components/drivers/include;board;board/CubeMX_Config/Core/Inc;libraries/HAL_Drivers;libraries/HAL_Drivers/config;rt-thread/components/finsh;.;rt-thread/include;rt-thread/components/libc/compilers/common;rt-thread/components/libc/compilers/common/none-gcc;libraries/STM32H7xx_HAL/STM32H7xx_HAL_Driver/Inc;libraries/STM32H7xx_HAL/CMSIS/Device/ST/STM32H7xx/Include;libraries/STM32H7xx_HAL/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group CPU
    rt-thread/libcpu/arm/common/: div0.c showmem.c backtrace.c
    rt-thread/libcpu/arm/cortex-m7/: cpuport.c cpu_cache.c context_rvds.S
  group DeviceDrivers
    rt-thread/components/drivers/misc/: pin.c
    rt-thread/components/drivers/src/: ringblk_buf.c dataqueue.c waitqueue.c pipe.c completion.c workqueue.c ringbuffer.c
    rt-thread/components/drivers/serial/: serial.c
  group Drivers
    board/: board.c
    board/CubeMX_Config/Core/Src/: stm32h7xx_hal_msp.c
    ../libraries/STM32H7xx_HAL/CMSIS/Device/ST/STM32H7xx/Source/Templates/arm/: startup_stm32h750xx.s
    libraries/HAL_Drivers/: drv_common.c drv_gpio.c drv_usart.c
  group finsh
    rt-thread/components/finsh/: cmd.c shell.c msh.c
  group Kernel
    rt-thread/src/: components.c irq.c clock.c idle.c device.c mempool.c timer.c kservice.c ipc.c object.c mem.c scheduler.c thread.c
  group libc
    rt-thread/components/libc/compilers/common/: time.c
  group Libraries
    libraries/STM32H7xx_HAL/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
    libraries/STM32H7xx_HAL/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_gpio.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_crc.c stm32h7xx_hal_rcc.c stm32h7xx_hal_pwr.c stm32h7xx_hal_cec.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_sram.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_usart.c stm32h7xx_hal_cortex.c stm32h7xx_hal_uart.c stm32h7xx_hal_dma.c stm32h7xx_hal_rng.c stm32h7xx_hal_cryp.c stm32h7xx_hal_mdma.c stm32h7xx_hal_comp.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_cryp_ex.c stm32h7xx_hal.c
